# Keil uVision project pac55xx_simple.uvprojx, settings and files
target pac55xx_simple (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PAC55XX Active-Semi
  pack: Active-Semi.PAC55XX.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pac55xx_simple +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .;.\pac55xx_sdk;.\pac55xx_sdk\device;.\pac55xx_sdk\driver;.\pac55xx_sdk\peripheral;.\pac55xx_sdk\boot_keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\pac55xx.sct
  group pac55xx_sdk
    ./pac55xx_sdk/boot_keil/: startup_pac55xx_keil.s system_pac5xxx.c system_pac5xxx.h
    ./pac55xx_sdk/driver/: pac5xxx_driver_adc.c pac5xxx_driver_adc.h pac5xxx_driver_config.h pac5xxx_driver_gpio.c pac5xxx_driver_gpio.h pac5xxx_driver_memory.h pac5xxx_driver_socbridge.c pac5xxx_driver_socbridge.h pac5xxx_driver_system.c pac5xxx_driver_system.h pac5xxx_driver_tile.h pac5xxx_driver_tile_socbridge.c pac5xxx_driver_timer.c pac5xxx_driver_timer.h pac5xxx_driver_uart.c pac5xxx_driver_uart.h pac5xxx_driver_can.c pac5xxx_driver_can.h
    ./pac55xx_sdk/peripheral/: pac5xxx.h pac5xxx_adc.h pac5xxx_can.h pac5xxx_crc.h pac5xxx_gp_timers.h pac5xxx_gpio.h pac5xxx_i2c.h pac5xxx_memory.h pac5xxx_rtc.h pac5xxx_scc.h pac5xxx_ssp.h pac5xxx_tile_driver_manager.h pac5xxx_tile_power_manager.h pac5xxx_tile_signal_manager.h pac5xxx_tile_system_manager.h pac5xxx_timers.h pac5xxx_uart.h pac5xxx_wwdt.h
    ./pac55xx_sdk/: pac5xxx_sdk_version.h
    ./pac55xx_sdk/device/: pac5523.h pac5532.h pac5524.h pac5556.h pac5527.h
  group src
    ./: main.c
software components: CMSIS:CORE 4.1.0
