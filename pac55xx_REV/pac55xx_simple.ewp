# IAR project pac55xx_simple.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PAC5523 PAC5523
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR
  ICCARM.CCIncludePath2: ; pac55xx_sdk; pac55xx_sdk\device; pac55xx_sdk\boot_IAR; pac55xx_sdk\driver; pac55xx_sdk\peripheral; pac55xx_sdk\src; pac55xx_sdk\src\can; pac55xx_sdk\src\gpio; pac55xx_sdk\src\init; pac55xx_sdk\src\uart; pac55xx_sdk\src\aio; pac55xx_sdk\src\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pac55xx_simple.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: pac55xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group pac55xx_sdk
    pac55xx_sdk/: pac5xxx_sdk_version.h
  group pac55xx_sdk/boot_IAR
    pac55xx_sdk/boot_IAR/: startup_pac55xx_iar.s
  group pac55xx_sdk/device
    pac55xx_sdk/device/: pac5523.h pac5524.h pac5527.h pac5532.h pac5556.h
  group pac55xx_sdk/driver
    pac55xx_sdk/driver/: pac5xxx_driver_adc.c pac5xxx_driver_adc.h pac5xxx_driver_can.c pac5xxx_driver_can.h pac5xxx_driver_config.h pac5xxx_driver_gpio.c pac5xxx_driver_gpio.h pac5xxx_driver_memory.h pac5xxx_driver_socbridge.c pac5xxx_driver_socbridge.h pac5xxx_driver_system.c pac5xxx_driver_system.h pac5xxx_driver_tile.h pac5xxx_driver_tile_socbridge.c pac5xxx_driver_timer.c pac5xxx_driver_timer.h pac5xxx_driver_uart.c pac5xxx_driver_uart.h
  group pac55xx_sdk/peripheral
    pac55xx_sdk/peripheral/: pac5xxx.h pac5xxx_adc.h pac5xxx_can.h pac5xxx_crc.h pac5xxx_gp_timers.h pac5xxx_gpio.h pac5xxx_i2c.h pac5xxx_memory.h pac5xxx_rtc.h pac5xxx_scc.h pac5xxx_ssp.h pac5xxx_tile_driver_manager.h pac5xxx_tile_power_manager.h pac5xxx_tile_signal_manager.h pac5xxx_tile_system_manager.h pac5xxx_timers.h pac5xxx_uart.h pac5xxx_wwdt.h
  group pac55xx_sdk/src
    pac55xx_sdk/src/: hs_functions.c
  group pac55xx_sdk/src/can
    pac55xx_sdk/src/can/: can_func.c can_func.h can_isr.c
  group pac55xx_sdk/src/common
    pac55xx_sdk/src/common/: common.c common.h
  group pac55xx_sdk/src/gpio
    pac55xx_sdk/src/gpio/: gpio_func.c gpio_func.h gpio_isr.c
  group pac55xx_sdk/src/init
    pac55xx_sdk/src/init/: init.c init.h
  group pac55xx_sdk/src/ISR_Handlers
    pac55xx_sdk/src/ISR_Handlers/: isr_adc.c isr_Stubs.c isr_TimerA.c isr_TimerB.c isr_TimerC.c isr_TimerD.c
  group pac55xx_sdk/src/state_machine
    pac55xx_sdk/src/state_machine/: state_machine.c state_machine.h
  group pac55xx_sdk/src/timer
    pac55xx_sdk/src/timer/: timer_func.h
  group pac55xx_sdk/src/uart
    pac55xx_sdk/src/uart/: uart_func.c uart_func.h uart_isr.c
